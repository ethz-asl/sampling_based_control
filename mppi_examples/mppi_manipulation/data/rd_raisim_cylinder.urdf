Commit message: more tuning of real-life controller for collision avoidance

File: mppi_examples/mppi_manipulation/data/rd_raisim_cylinder.urdf (robot description, URDF)
Before this commit: robot panda, 35 links, 34 joints
Links:
- link base_link: geometry collision box size=1.0 0.75 0.65
